# Keil uVision project LOOPBACK-KEIL.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LOOPBACK-KEIL +hex
  c flags: Optim=1
  c include: .\include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group LIB
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_crc.c
  group USER
    ./source/: adc.c alarm.c at24c16.c DS1302.c flash.c gsm.c main.c stm32f10x_it.c system_stm32f10x.c util.c keys.c screan.c voice.c
    ./source/W5500/: md5.c socket.c SPI2.c w5500.c
    ./source/APPs/: loopback.c
